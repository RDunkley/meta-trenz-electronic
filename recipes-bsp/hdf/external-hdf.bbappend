###################################################################################################
# Appends the HDF file for various Trenz-Electronic boards.
# Copyright Richard Dunkley 2020
###################################################################################################

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

HDF_EXT_te0820-03-03eg = "hdf"
HDF_BASE_te0820-03-03eg = "file://"
HDF_PATH_te0820-03-03eg = "te0820-03-03eg.hdf"

